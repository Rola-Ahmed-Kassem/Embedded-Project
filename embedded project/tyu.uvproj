# Keil uVision project tyu.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: tyu
  c flags: Optim=1 OneElfS=1
  c misc: -c99
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s yu.c system_TM4C123.c Delay.c BIT_PATH.h delay.h funcUart.h GPS_Config.h GPS_Interface.h GPS_private.h STD_TYPES.h UART_interface.h SysTick-1.c SysTick-1.h LCD_-1.h LCD_-2.c
